# HomeAgent: wayland-protocols 1.33 → 1.34 업그레이드
# Mesa 24.2+에서 wayland-protocols >= 1.34 요구
PV = "1.34"
SRC_URI = "https://gitlab.freedesktop.org/wayland/wayland-protocols/-/releases/${PV}/downloads/wayland-protocols-${PV}.tar.xz"
SRC_URI[sha256sum] = "c59b27cacd85f60baf4ee5f80df5c0d15760ead6a2432b00ab7e2e0574dcafeb"
